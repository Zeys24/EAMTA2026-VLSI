v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 0 -230 0 0 {lab=#net1}
N -10 -230 0 -230 {lab=#net1}
N 430 0 430 30 {lab=#net2}
N 510 0 650 0 {lab=#net2}
N 650 0 650 30 {lab=#net2}
N 650 90 650 130 {lab=VSS}
N 510 130 650 130 {lab=VSS}
N 430 90 430 130 {lab=VSS}
N 370 60 390 60 {lab=clr}
N 370 -30 370 60 {lab=clr}
N 370 -60 470 -60 {lab=clr}
N 510 -30 510 0 {lab=#net2}
N 430 0 510 0 {lab=#net2}
N 690 60 720 60 {lab=#net3}
N 720 -160 720 60 {lab=#net3}
N 510 -130 510 -90 {lab=#net4}
N 0 -270 0 -230 {lab=#net1}
N 1100 -170 1100 -140 {lab=Q}
N 1180 -170 1320 -170 {lab=Q}
N 1320 -170 1320 -140 {lab=Q}
N 1320 -80 1320 -40 {lab=#net5}
N 1190 -40 1320 -40 {lab=#net5}
N 1100 -80 1100 -40 {lab=#net5}
N 1180 -200 1180 -170 {lab=Q}
N 1100 -170 1180 -170 {lab=Q}
N 1180 -300 1180 -260 {lab=#net6}
N 1040 -110 1060 -110 {lab=#net7}
N 1040 -230 1140 -230 {lab=#net7}
N 1360 -110 1380 -110 {lab=clr}
N 1380 -290 1380 -110 {lab=clr}
N 1220 -330 1380 -330 {lab=clr}
N -220 -280 -180 -280 {lab=D}
N 260 -0 430 -0 {lab=#net2}
N 1530 100 1590 100 {lab=Q'}
N 1040 -230 1040 -110 {lab=#net7}
N -0 -0 90 -0 {lab=#net1}
N -200 -380 -170 -380 {lab=clr}
N -200 -400 -170 -400 {lab=clk}
N 0 -270 70 -270 {lab=#net1}
N 1530 40 1530 100 {lab=Q'}
N 1240 100 1530 100 {lab=Q'}
N 1530 -170 1530 -110 {lab=Q}
N 1320 -170 1530 -170 {lab=Q}
N -140 -510 -80 -510 {lab=clk}
N 70 -510 120 -510 {lab=clk'}
N -230 -240 -180 -240 {lab=clk}
N -230 -220 -180 -220 {lab=clk'}
N 40 40 90 40 {lab=clk}
N 40 60 90 60 {lab=clk'}
N 1020 90 1070 90 {lab=clk}
N 1020 110 1070 110 {lab=clk'}
N -200 -360 -170 -360 {lab=VDD}
N -50 -590 -50 -560 {lab=VDD}
N 1580 10 1630 10 {lab=VSS}
N 1450 10 1480 10 {lab=VDD}
N -50 -460 -50 -420 {lab=VSS}
N 100 -230 100 -190 {lab=VSS}
N 510 130 510 160 {lab=VSS}
N 430 130 510 130 {lab=VSS}
N 1190 -40 1190 -20 {lab=#net5}
N 1100 -40 1190 -40 {lab=#net5}
N 1530 -170 1600 -170 {lab=Q}
N -200 -340 -170 -340 {lab=VSS}
N 510 -200 530 -200 {lab=VDD}
N 510 -200 510 -190 {lab=VDD}
N 440 -160 510 -160 {lab=VDD}
N 510 -60 580 -60 {lab=VDD}
N 500 60 650 60 {lab=VSS}
N 500 50 500 60 {lab=VSS}
N 430 60 500 60 {lab=VSS}
N 500 50 520 50 {lab=VSS}
N 1100 -330 1180 -330 {lab=VDD}
N 1180 -230 1260 -230 {lab=VDD}
N 1190 -110 1320 -110 {lab=VSS}
N 1190 -150 1190 -110 {lab=VSS}
N 1100 -110 1190 -110 {lab=VSS}
N 1180 -390 1180 -360 {lab=VDD}
N 1380 -290 1410 -290 {lab=clr}
N 1380 -330 1380 -290 {lab=clr}
N 370 -30 400 -30 {lab=clr}
N 370 -60 370 -30 {lab=clr}
N -200 -320 -170 -320 {lab=D}
N 630 -160 720 -160 {lab=#net3}
N 630 -270 630 -160 {lab=#net3}
N 550 -160 630 -160 {lab=#net3}
N 220 -270 630 -270 {lab=#net3}
N -10 -260 -10 -230 {lab=#net1}
N -110 -190 -110 -170 {lab=VSS}
N 630 -270 700 -270 {lab=#net3}
N 870 -250 870 -230 {lab=#net7}
N 870 -230 1040 -230 {lab=#net7}
N 260 0 260 20 {lab=#net2}
N 1040 50 1070 50 {lab=#net7}
N 1040 -110 1040 50 {lab=#net7}
N 1240 70 1240 100 {lab=Q'}
N 160 90 160 110 {lab=VSS}
N 770 -180 770 -160 {lab=VSS}
N 1140 140 1140 150 {lab=VSS}
N 160 -50 160 -40 {lab=VDD}
N 1140 0 1140 10 {lab=VDD}
N 770 -330 770 -310 {lab=VDD}
N -110 -340 -110 -320 {lab=VDD}
N 100 -360 100 -320 {lab=VDD}
C {sg13g2_pr/sg13_lv_nmos.sym} 410 60 0 0 {name=M8
l=0.15u
w=0.75u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 670 60 0 1 {name=M9
l=0.15u
w=0.75u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 490 -60 0 0 {name=M7
l=0.15u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 530 -160 0 1 {name=M6
l=0.15u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1080 -110 0 0 {name=M10
l=0.15u
w=0.75u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1340 -110 0 1 {name=M11
l=0.15u
w=0.75u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1160 -230 0 0 {name=M12
l=0.15u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1200 -330 0 1 {name=M13
l=0.15u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {iopin.sym} -200 -400 2 0 {name=p1 lab=clk}
C {lab_pin.sym} -220 -280 0 0 {name=p2 sig_type=std_logic lab=D}
C {iopin.sym} -200 -380 2 0 {name=p3 lab=clr}
C {lab_pin.sym} -170 -400 2 0 {name=p4 sig_type=std_logic lab=clk}
C {lab_pin.sym} -170 -380 2 0 {name=p5 sig_type=std_logic lab=clr}
C {lab_pin.sym} -140 -510 0 0 {name=p6 sig_type=std_logic lab=clk}
C {lab_pin.sym} 120 -510 2 0 {name=p7 sig_type=std_logic lab=clk'}
C {lab_pin.sym} -230 -220 0 0 {name=p8 sig_type=std_logic lab=clk'}
C {lab_pin.sym} -230 -240 0 0 {name=p9 sig_type=std_logic lab=clk}
C {lab_pin.sym} 40 60 0 0 {name=p10 sig_type=std_logic lab=clk'}
C {lab_pin.sym} 40 40 0 0 {name=p11 sig_type=std_logic lab=clk}
C {lab_pin.sym} 700 -210 0 0 {name=p12 sig_type=std_logic lab=clk'}
C {lab_pin.sym} 700 -230 0 0 {name=p13 sig_type=std_logic lab=clk}
C {lab_pin.sym} 1020 110 0 0 {name=p14 sig_type=std_logic lab=clk'}
C {lab_pin.sym} 1020 90 0 0 {name=p15 sig_type=std_logic lab=clk}
C {iopin.sym} -200 -360 2 0 {name=p16 lab=VDD}
C {iopin.sym} 1600 -170 0 0 {name=p17 lab=Q}
C {lab_pin.sym} -170 -360 2 0 {name=p18 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -50 -590 1 0 {name=p21 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 100 -360 1 0 {name=p22 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1450 10 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {iopin.sym} 1590 100 0 0 {name=p19 lab=Q'}
C {iopin.sym} -200 -340 2 0 {name=p20 lab=VSS}
C {lab_pin.sym} -170 -340 2 0 {name=p23 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 520 50 0 1 {name=p24 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 530 -200 2 0 {name=p25 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 440 -160 2 1 {name=p27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1100 -330 2 1 {name=p29 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1190 -150 2 0 {name=p31 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1180 -390 2 0 {name=p32 sig_type=std_logic lab=VDD}
C {blocks/inverter/inverter.sym} 220 -270 0 0 {name=x8}
C {blocks/inverter/inverter.sym} 70 -510 0 0 {name=x5}
C {blocks/inverter/inverter.sym} 1530 -110 3 0 {name=x7}
C {lab_pin.sym} 1410 -290 2 0 {name=p34 sig_type=std_logic lab=clr}
C {lab_pin.sym} 400 -30 2 0 {name=p33 sig_type=std_logic lab=clr}
C {iopin.sym} -200 -320 2 0 {name=p35 lab=D}
C {lab_pin.sym} -170 -320 0 1 {name=p36 sig_type=std_logic lab=D}
C {blocks/transmissiongate/transmissiongate.sym} -30 -240 0 0 {name=x1}
C {lab_pin.sym} -110 -340 2 0 {name=p37 sig_type=std_logic lab=VDD}
C {blocks/transmissiongate/transmissiongate.sym} 850 -230 0 0 {name=x2}
C {blocks/transmissiongate/transmissiongate.sym} 240 40 0 0 {name=x3}
C {blocks/transmissiongate/transmissiongate.sym} 1220 90 0 0 {name=x4}
C {lab_pin.sym} -110 -170 2 0 {name=p39 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 160 110 2 0 {name=p40 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 770 -160 2 0 {name=p41 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1140 150 2 0 {name=p42 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 160 -50 2 0 {name=p43 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 770 -330 2 0 {name=p44 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1140 0 2 0 {name=p45 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 580 -60 2 0 {name=p26 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1260 -230 2 0 {name=p38 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 1630 10 2 0 {name=p30 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 100 -190 2 0 {name=p46 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -50 -420 2 0 {name=p47 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 510 160 0 1 {name=p48 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1190 -20 2 0 {name=p49 sig_type=std_logic lab=VSS}
